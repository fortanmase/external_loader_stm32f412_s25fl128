# Keil uVision project NewDevice.uvprojx, settings and files
target Cortex-M (6190000::V6.19::ARMCLANG)
  device: STM32H755ZITx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: IRAM(0x38000000,0x00010000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) XRAM(0x20000000,0x00020000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: NewDevice
  AfterMake: cmd.exe /C copy "Objects\%L"  "C:\legacy\Keil_v5\ARM\Flash\STM32F412_S25FL128L.FLM"
  c flags: Optim=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_HAL_DRIVER,STM32F412Zx
  c include: .\Drivers\CMSIS\Device\ST\STM32F4xx\Include;.\Drivers\CMSIS\Include;.\Drivers\STM32F4xx_HAL_Driver\Inc\Legacy;.\Drivers\STM32F4xx_HAL_Driver\Inc;.\Core\Inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT6: RAM 0x20000000 size 0x20000
  memory RVCT9: RAM 0x38000000 size 0x10000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Documentation
    ./: Abstract.txt
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
  group Core
    ./Core/Src/: main.c stm32f4xx_hal_msp.c stm32f4xx_it.c system_stm32f4xx.c s25fl128s.c
  group Drivers
    ./Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_qspi.c
